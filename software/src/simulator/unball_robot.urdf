Commit message: Tweaking simulation parameters to make more realistic robot movements.

File: software/src/simulator/unball_robot.urdf (robot description, URDF)
Before this commit: robot test_robot, 3 links, 2 joints
Links:
- link base_link: mass 1.0 -> 0.2
